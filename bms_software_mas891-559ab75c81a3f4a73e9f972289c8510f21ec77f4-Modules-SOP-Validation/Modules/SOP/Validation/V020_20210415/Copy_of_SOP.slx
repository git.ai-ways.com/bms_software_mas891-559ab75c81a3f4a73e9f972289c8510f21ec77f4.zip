simulink model "Copy_of_SOP"  (R2017b)
settings: Solver=FixedStepDiscrete  StartTime=0.0  StopTime=10.0  FixedStep=0.01  RelTol=1e-3  EnableMultiTasking=on
undefined symbols (not defined in the file): ASWTYPE_FALSE, ASWTYPE_TRUE, CcSOP_CellVoltLowLevel1Time_MS, CcSOP_CellVoltRngDiff_V, CcSOP_CellVoltRngDiffHeal_V, CcSOP_CellVoltRngHighTime_MS, CcSOP_CellVoltRngLowTime_MS, CcSOP_CellVoltRngUpLimit_V, CcSOP_ChrgCurrFltChrgCurrThrld_A, CcSOP_ChrgCurrFltLevel1Factor_numb, CcSOP_ChrgCurrFltLevel1Time_ms, CcSOP_ChrgCurrFltLevel2Factor_numb, CcSOP_ChrgCurrFltLevel2Time_ms, CcSOP_ChrgCurrFltLevel3Factor_numb, CcSOP_ChrgCurrFltLevel3Time_ms, CcSOP_ChrgFloorPwrLimit_kW, CcSOP_ChrgFltHysCurr_A, CcSOP_ChrgHighFactor_numb, CcSOP_ChrgLowFactor_numb, CcSOP_ChrgPwrFltPeakPwrThrld_kW, CcSOP_DisChrgEmerPwrLimit_kW, CcSOP_DisChrgFloorPwrLimit_kW, CcSOP_DisChrgHighFactor_numb, CcSOP_DisChrgLowFactor_numb, CcSOP_DischrgPwrFltLevel1Factor_numb, CcSOP_DischrgPwrFltLevel1Time_ms, CcSOP_DischrgPwrFltLevel2Factor_numb, CcSOP_DischrgPwrFltLevel2Time_ms, CcSOP_DischrgPwrFltLevel3Factor_numb, CcSOP_DischrgPwrFltLevel3Time_ms, CcSOP_DischrgPwrFltPeakPwrThrld_kW, CcSOP_DischrgPwrFltThrld_kW, CcSOP_DisChrgPwrLimit_kW, CcSOP_FeedbackPwrFltLevel1Factor_numb, CcSOP_FeedbackPwrFltLevel1Time_ms, CcSOP_FeedbackPwrFltLevel2Factor_numb, CcSOP_FeedbackPwrFltLevel2Time_ms, CcSOP_FeedbackPwrFltLevel3Factor_numb, CcSOP_FeedbackPwrFltLevel3Time_ms, CcSOP_FeedbackPwrFltThrld_kW, CcSOP_FltLimitPwrFactorLevel1_numb, CcSOP_FltLimitPwrFactorLevel2_numb, CcSOP_LookupTablePwrFactor_pct, CcSOP_MaxChrgCurrLimitFactorLevel2_numb, CcSOP_MaxCurrTableLarger_ms, CcSOP_MaxCurrTableSmaller_ms, CcSOP_PeakPowerRunTime_ms, CcSOP_PwrDownDisDetLevel1Speed_kW, CcSOP_PwrDownDisFloorFactor_numb, CcSOP_PwrDownDisFloorSpeed_kW, CcSOP_PwrDownSpeed_kW, CcSOP_PwrFltHysFactor_numb, CcSOP_PwrFltThrldTestMode_kW, CcSOP_PwrUpSpeed_kW, Enum_CTCCtrCtlConnMode, Enum_CTCCtrCtlState, Enum_MSMBMUState, Enum_SOPChrgPwrState, Enum_SOPDisChrgPwrState, Enum_SOPFeedbackPwrState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
libraries: AIWAYS_Powertrain_BMS_lib x77
(part 4 of 4)

== system Copy_of_SOP/SOP/SOP_10ms/SOP_10ms_sys/PwrAlarm/ChrgState/ChrgStateFltLevel1 ==
  LcSOP_ChrgRqstCurr_A : Inport
  GcHDP_PackCrnt_A : Inport  Port=2
  Enable : EnablePort  StatesWhenEnabling=reset
  Add : Sum  OutDataTypeStr=Inherit: Inherit via back propagation
  Add1 : Sum  Inputs=+-
  Bus Creator : BusCreator  Inputs=2
  Bus Selector : BusSelector  OutputSignals=GcHDP_PackCrnt_A,LcSOP_ChrgRqstCurr_A
  Bus Selector1 : BusSelector  OutputSignals=GcHDP_PackCrnt_A,LcSOP_ChrgRqstCurr_A
  Constant : Constant  Value=CcSOP_ChrgCurrFltLevel2Factor_numb
  Constant1 : Constant  Value=CcSOP_ChrgFltHysCurr_A
  Constant2 : Constant  Value=CcSOP_ChrgCurrFltLevel2Time_ms
  Constant3 : Constant  Value=SOP_RUNTIME_MS
  Constant4 : Constant  Value=CcSOP_ChrgCurrFltLevel1Factor_numb
  Constant5 : Constant  Value=CcSOP_ChrgFltHysCurr_A
  Constant6 : Constant  Value=CcSOP_ChrgCurrFltLevel1Time_ms
  Constant7 : Constant  Value=SOP_RUNTIME_MS
  Constant8 : Constant  Value=SOP_CONSTF1_NUMB
  Constant9 : Constant  Value=SOP_CONSTF1_NUMB
  DebounceStartZero : AIWAYS_Powertrain_BMS_lib/Debounce & Delay/BMSDebounceStartZero
  DebounceStartZero1 : AIWAYS_Powertrain_BMS_lib/Debounce & Delay/BMSDebounceStartZero
  Divide : Product  Inputs=**  OutDataTypeStr=Inherit: Inherit via back propagation
  Divide1 : Product  Inputs=**
  Product : Product
  Product1 : Product
  Relational Operator : RelationalOperator  OutDataTypeStr=boolean
  Relational Operator1 : RelationalOperator  Operator=<=  OutDataTypeStr=boolean
  LbSOP_ChrgPwrLevel12Level2_flg : Outport
  LbSOP_ChrgPwrLevel12Normal_flg : Outport  Port=2
  wires:
  Relational Operator1/1 -> DebounceStartZero1/1
  Product1/1 -> Relational Operator1/1
  Product/1 -> Relational Operator/1
  Relational Operator/1 -> DebounceStartZero/1
  Add1/1 -> Relational Operator1/2
  Constant5/1 -> Add1/2
  Constant4/1 -> Divide1/2
  Constant1/1 -> Add/2
  Add/1 -> Relational Operator/2
  Divide/1 -> Add/1
  Constant/1 -> Divide/2
  DebounceStartZero/1 -> LbSOP_ChrgPwrLevel12Level2_flg/1  "LbSOP_ChrgPwrLevel12Level2_flg"
  Constant3/1 -> DebounceStartZero/5, DebounceStartZero/3
  Constant2/1 -> DebounceStartZero/2, DebounceStartZero/4
  LcSOP_ChrgRqstCurr_A/1 -> Bus Creator/2
  GcHDP_PackCrnt_A/1 -> Bus Creator/1
  Bus Selector/1 -> Product/2  "<GcHDP_PackCrnt_A>"
  Bus Selector/2 -> Divide/1  "<LcSOP_ChrgRqstCurr_A>"
  DebounceStartZero1/1 -> LbSOP_ChrgPwrLevel12Normal_flg/1  "LbSOP_ChrgPwrLevel12Normal_flg"
  Constant7/1 -> DebounceStartZero1/3, DebounceStartZero1/5
  Constant6/1 -> DebounceStartZero1/4, DebounceStartZero1/2
  Divide1/1 -> Add1/1
  Bus Creator/1 -> Bus Selector/1, Bus Selector1/1
  Bus Selector1/2 -> Divide1/1  "<LcSOP_ChrgRqstCurr_A>"
  Bus Selector1/1 -> Product1/2  "<GcHDP_PackCrnt_A>"
  Constant8/1 -> Product/1
  Constant9/1 -> Product1/1

== system Copy_of_SOP/SOP/SOP_10ms/SOP_10ms_sys/PwrAlarm/ChrgState/ChrgStateFltLevel2 ==
  LcSOP_ChrgRqstCurr_A : Inport
  GcHDP_PackCrnt_A : Inport  Port=2
  Enable : EnablePort  StatesWhenEnabling=reset
  Add : Sum
  Add1 : Sum  Inputs=+-
  Bus Creator : BusCreator  Inputs=2
  Bus Selector : BusSelector  OutputSignals=GcHDP_PackCrnt_A,LcSOP_ChrgRqstCurr_A
  Bus Selector1 : BusSelector  OutputSignals=GcHDP_PackCrnt_A,LcSOP_ChrgRqstCurr_A
  Constant : Constant  Value=CcSOP_ChrgCurrFltLevel3Factor_numb
  Constant1 : Constant  Value=CcSOP_ChrgFltHysCurr_A
  Constant2 : Constant  Value=CcSOP_ChrgCurrFltLevel3Time_ms
  Constant3 : Constant  Value=SOP_RUNTIME_MS
  Constant4 : Constant  Value=CcSOP_ChrgCurrFltLevel2Factor_numb
  Constant5 : Constant  Value=CcSOP_ChrgFltHysCurr_A
  Constant6 : Constant  Value=CcSOP_ChrgCurrFltLevel2Time_ms
  Constant7 : Constant  Value=SOP_RUNTIME_MS
  Constant8 : Constant  Value=SOP_CONSTF1_NUMB
  Constant9 : Constant  Value=SOP_CONSTF1_NUMB
  DebounceStartZero : AIWAYS_Powertrain_BMS_lib/Debounce & Delay/BMSDebounceStartZero
  DebounceStartZero1 : AIWAYS_Powertrain_BMS_lib/Debounce & Delay/BMSDebounceStartZero
  Divide : Product  Inputs=**
  Divide1 : Product  Inputs=**
  Product : Product
  Product1 : Product
  Relational Operator1 : RelationalOperator  Operator=<=  OutDataTypeStr=boolean
  Relational Operator2 : RelationalOperator  OutDataTypeStr=boolean
  LbSOP_ChrgPwrLevel22Level3_flg : Outport
  LbSOP_ChrgPwrLevel22Level1_flg : Outport  Port=2
  wires:
  Add1/1 -> Relational Operator1/2
  Relational Operator1/1 -> DebounceStartZero1/1
  Bus Selector1/1 -> Product1/2  "<GcHDP_PackCrnt_A>"
  Product1/1 -> Relational Operator1/1
  Constant5/1 -> Add1/2
  Divide1/1 -> Add1/1
  Bus Selector1/2 -> Divide1/1  "<LcSOP_ChrgRqstCurr_A>"
  Constant4/1 -> Divide1/2
  Add/1 -> Relational Operator2/2
  Bus Selector/1 -> Product/2  "<GcHDP_PackCrnt_A>"
  Constant1/1 -> Add/2
  Constant/1 -> Divide/2
  Product/1 -> Relational Operator2/1
  Relational Operator2/1 -> DebounceStartZero/1
  Bus Creator/1 -> Bus Selector/1, Bus Selector1/1
  Constant6/1 -> DebounceStartZero1/2, DebounceStartZero1/4
  Constant7/1 -> DebounceStartZero1/5, DebounceStartZero1/3
  DebounceStartZero1/1 -> LbSOP_ChrgPwrLevel22Level1_flg/1  "LbSOP_ChrgPwrLevel22Level1_flg"
  Bus Selector/2 -> Divide/1  "<LcSOP_ChrgRqstCurr_A>"
  GcHDP_PackCrnt_A/1 -> Bus Creator/1
  LcSOP_ChrgRqstCurr_A/1 -> Bus Creator/2
  Divide/1 -> Add/1
  Constant2/1 -> DebounceStartZero/4, DebounceStartZero/2
  Constant3/1 -> DebounceStartZero/3, DebounceStartZero/5
  DebounceStartZero/1 -> LbSOP_ChrgPwrLevel22Level3_flg/1  "LbSOP_ChrgPwrLevel22Level3_flg"
  Constant8/1 -> Product/1
  Constant9/1 -> Product1/1

== system Copy_of_SOP/SOP/SOP_10ms/SOP_10ms_sys/PwrAlarm/ChrgState/ChrgStateFltLevel3 ==
  LcSOP_ChrgRqstCurr_A : Inport
  GcHDP_PackCrnt_A : Inport  Port=2
  Enable : EnablePort  StatesWhenEnabling=reset
  Add1 : Sum  Inputs=+-
  Constant4 : Constant  Value=CcSOP_ChrgCurrFltLevel3Factor_numb
  Constant5 : Constant  Value=CcSOP_ChrgFltHysCurr_A
  Constant6 : Constant  Value=CcSOP_ChrgCurrFltLevel2Time_ms
  Constant7 : Constant  Value=SOP_RUNTIME_MS
  Constant8 : Constant  Value=SOP_CONSTF1_NUMB
  DebounceStartZero1 : AIWAYS_Powertrain_BMS_lib/Debounce & Delay/BMSDebounceStartZero
  Divide1 : Product  Inputs=**
  Product : Product
  Relational Operator2 : RelationalOperator  Operator=<=  OutDataTypeStr=boolean
  LbSOP_ChrgPwrLevel32Level2_flg : Outport
  wires:
  Add1/1 -> Relational Operator2/2
  Constant5/1 -> Add1/2
  LcSOP_ChrgRqstCurr_A/1 -> Divide1/1
  Constant4/1 -> Divide1/2
  Product/1 -> Relational Operator2/1
  DebounceStartZero1/1 -> LbSOP_ChrgPwrLevel32Level2_flg/1  "LbSOP_ChrgPwrLevel32Level2_flg"
  Constant7/1 -> DebounceStartZero1/3, DebounceStartZero1/5
  Constant6/1 -> DebounceStartZero1/4, DebounceStartZero1/2
  Relational Operator2/1 -> DebounceStartZero1/1
  Divide1/1 -> Add1/1
  GcHDP_PackCrnt_A/1 -> Product/2
  Constant8/1 -> Product/1

== system Copy_of_SOP/SOP/SOP_10ms/SOP_10ms_sys/PwrAlarm/ChrgState/ChrgStateNormal ==
  LcSOP_ChrgRqstCurr_A : Inport
  GcHDP_PackCrnt_A : Inport  Port=2
  Enable : EnablePort  StatesWhenEnabling=reset
  Add : Sum
  Constant : Constant  Value=CcSOP_ChrgCurrFltLevel1Factor_numb
  Constant1 : Constant  Value=CcSOP_ChrgFltHysCurr_A
  Constant2 : Constant  Value=CcSOP_ChrgCurrFltLevel1Time_ms
  Constant3 : Constant  Value=SOP_RUNTIME_MS
  Constant8 : Constant  Value=SOP_CONSTF1_NUMB
  DebounceStartZero : AIWAYS_Powertrain_BMS_lib/Debounce & Delay/BMSDebounceStartZero
  Divide : Product  Inputs=**
  Product : Product
  Relational Operator : RelationalOperator  OutDataTypeStr=boolean
  LbSOP_ChrgPwrNormal2Level1_flg : Outport
  wires:
  Relational Operator/1 -> DebounceStartZero/1
  Product/1 -> Relational Operator/1
  GcHDP_PackCrnt_A/1 -> Product/2
  Add/1 -> Relational Operator/2
  Divide/1 -> Add/1
  Constant/1 -> Divide/2
  LcSOP_ChrgRqstCurr_A/1 -> Divide/1
  Constant1/1 -> Add/2
  Constant2/1 -> DebounceStartZero/4, DebounceStartZero/2
  Constant3/1 -> DebounceStartZero/3, DebounceStartZero/5
  DebounceStartZero/1 -> LbSOP_ChrgPwrNormal2Level1_flg/1  "LbSOP_ChrgPwrNormal2Level1_flg"
  Constant8/1 -> Product/1

== system Copy_of_SOP/SOP/SOP_10ms/SOP_10ms_sys/PwrAlarm/DischrgState/DischrgStateFltLevel1 ==
  LcSOP_PackDisChrgPeakTablePwr_kW : Inport
  LcSOP_CurrPwr_kW : Inport  Port=2
  Enable : EnablePort  StatesWhenEnabling=reset
  Add : Sum
  Add1 : Sum  Inputs=+-
  Add2 : Sum  Inputs=+-
  Constant : Constant  Value=CcSOP_DischrgPwrFltLevel2Factor_numb
  Constant1 : Constant  Value=CcSOP_PwrFltHysFactor_numb
  Constant2 : Constant  Value=CcSOP_DischrgPwrFltLevel2Time_ms
  Constant3 : Constant  Value=SOP_RUNTIME_MS
  Constant4 : Constant  Value=CcSOP_DischrgPwrFltLevel1Factor_numb
  Constant5 : Constant  Value=CcSOP_PwrFltHysFactor_numb
  Constant6 : Constant  Value=CcSOP_DischrgPwrFltLevel1Time_ms
  Constant7 : Constant  Value=SOP_RUNTIME_MS
  Constant8 : Constant  Value=CcSOP_DischrgPwrFltThrld_kW
  DebounceStartZero : AIWAYS_Powertrain_BMS_lib/Debounce & Delay/BMSDebounceStartZero
  DebounceStartZero1 : AIWAYS_Powertrain_BMS_lib/Debounce & Delay/BMSDebounceStartZero
  Demux : Demux  Outputs=2
  Demux1 : Demux  Outputs=2
  Demux2 : Demux  Outputs=2
  Divide : Product  Inputs=**
  Divide1 : Product  Inputs=**
  Logical Operator : Logic  AllPortsSameDT=off  OutDataTypeStr=boolean
  Mux : Mux  Inputs=2
  Relational Operator : RelationalOperator  OutDataTypeStr=boolean
  Relational Operator1 : RelationalOperator  Operator=<=  OutDataTypeStr=boolean
  Relational Operator2 : RelationalOperator  OutDataTypeStr=boolean
  LbSOP_DischrgPwrLevel12Level2_flg : Outport
  LbSOP_DischrgPwrLevel12Normal_flg : Outport  Port=2
  wires:
  Demux1/1 -> Relational Operator1/1
  Demux1/2 -> Divide1/1
  Mux/1 -> Demux/1, Demux1/1, Demux2/1
  Constant4/1 -> Add1/1
  Constant5/1 -> Add1/2
  Add1/1 -> Divide1/2
  Divide1/1 -> Relational Operator1/2
  Relational Operator1/1 -> DebounceStartZero1/1
  Constant6/1 -> DebounceStartZero1/2, DebounceStartZero1/4
  Constant7/1 -> DebounceStartZero1/5, DebounceStartZero1/3
  DebounceStartZero1/1 -> LbSOP_DischrgPwrLevel12Normal_flg/1  "LbSOP_DischrgPwrLevel12Normal_flg"
  Demux/2 -> Divide/1
  LcSOP_CurrPwr_kW/1 -> Mux/1
  LcSOP_PackDisChrgPeakTablePwr_kW/1 -> Mux/2
  Constant/1 -> Add/1
  Constant1/1 -> Add/2
  Add/1 -> Divide/2
  Divide/1 -> Relational Operator/2
  Constant2/1 -> DebounceStartZero/2, DebounceStartZero/4
  Constant3/1 -> DebounceStartZero/3, DebounceStartZero/5
  DebounceStartZero/1 -> LbSOP_DischrgPwrLevel12Level2_flg/1  "LbSOP_DischrgPwrLevel12Level2_flg"
  Demux/1 -> Relational Operator/1
  Constant8/1 -> Relational Operator2/2
  Logical Operator/1 -> DebounceStartZero/1
  Relational Operator/1 -> Logical Operator/2
  Relational Operator2/1 -> Logical Operator/1
  Demux2/1 -> Add2/1
  Demux2/2 -> Add2/2
  Add2/1 -> Relational Operator2/1

== system Copy_of_SOP/SOP/SOP_10ms/SOP_10ms_sys/PwrAlarm/DischrgState/DischrgStateFltLevel2 ==
  LcSOP_PackDisChrgPeakTablePwr_kW : Inport
  LcSOP_CurrPwr_kW : Inport  Port=2
  Enable : EnablePort  StatesWhenEnabling=reset
  Add : Sum
  Add1 : Sum  Inputs=+-
  Add2 : Sum  Inputs=+-
  Constant : Constant  Value=CcSOP_DischrgPwrFltLevel3Factor_numb
  Constant1 : Constant  Value=CcSOP_PwrFltHysFactor_numb
  Constant2 : Constant  Value=CcSOP_DischrgPwrFltLevel3Time_ms
  Constant3 : Constant  Value=SOP_RUNTIME_MS
  Constant4 : Constant  Value=CcSOP_DischrgPwrFltLevel2Factor_numb
  Constant5 : Constant  Value=CcSOP_PwrFltHysFactor_numb
  Constant6 : Constant  Value=CcSOP_DischrgPwrFltLevel2Time_ms
  Constant7 : Constant  Value=SOP_RUNTIME_MS
  Constant8 : Constant  Value=CcSOP_DischrgPwrFltThrld_kW
  DebounceStartZero : AIWAYS_Powertrain_BMS_lib/Debounce & Delay/BMSDebounceStartZero
  DebounceStartZero1 : AIWAYS_Powertrain_BMS_lib/Debounce & Delay/BMSDebounceStartZero
  Demux : Demux  Outputs=2
  Demux1 : Demux  Outputs=2
  Demux2 : Demux  Outputs=2
  Divide : Product  Inputs=**
  Divide1 : Product  Inputs=**
  Logical Operator : Logic  AllPortsSameDT=off  OutDataTypeStr=boolean
  Mux : Mux  Inputs=2
  Relational Operator : RelationalOperator  OutDataTypeStr=boolean
  Relational Operator1 : RelationalOperator  Operator=<=  OutDataTypeStr=boolean
  Relational Operator2 : RelationalOperator  OutDataTypeStr=boolean
  LbSOP_DischrgPwrLevel22Level3_flg : Outport
  LbSOP_DischrgPwrLevel22Level1_flg : Outport  Port=2
  wires:
  DebounceStartZero/1 -> LbSOP_DischrgPwrLevel22Level3_flg/1  "LbSOP_DischrgPwrLevel22Level3_flg"
  Constant3/1 -> DebounceStartZero/5, DebounceStartZero/3
  Constant2/1 -> DebounceStartZero/2, DebounceStartZero/4
  Divide/1 -> Relational Operator/2
  Add/1 -> Divide/2
  Constant1/1 -> Add/2
  Constant/1 -> Add/1
  LcSOP_PackDisChrgPeakTablePwr_kW/1 -> Mux/2
  LcSOP_CurrPwr_kW/1 -> Mux/1
  Demux/2 -> Divide/1
  DebounceStartZero1/1 -> LbSOP_DischrgPwrLevel22Level1_flg/1  "LbSOP_DischrgPwrLevel22Level1_flg"
  Constant7/1 -> DebounceStartZero1/3, DebounceStartZero1/5
  Constant6/1 -> DebounceStartZero1/4, DebounceStartZero1/2
  Relational Operator1/1 -> DebounceStartZero1/1
  Divide1/1 -> Relational Operator1/2
  Add1/1 -> Divide1/2
  Constant5/1 -> Add1/2
  Constant4/1 -> Add1/1
  Mux/1 -> Demux2/1, Demux1/1, Demux/1
  Demux1/2 -> Divide1/1
  Demux1/1 -> Relational Operator1/1
  Demux/1 -> Relational Operator/1
  Constant8/1 -> Relational Operator2/2
  Add2/1 -> Relational Operator2/1
  Demux2/1 -> Add2/1
  Demux2/2 -> Add2/2
  Logical Operator/1 -> DebounceStartZero/1
  Relational Operator/1 -> Logical Operator/2
  Relational Operator2/1 -> Logical Operator/1

== system Copy_of_SOP/SOP/SOP_10ms/SOP_10ms_sys/PwrAlarm/DischrgState/DischrgStateFltLevel3 ==
  LcSOP_PackDisChrgPeakTablePwr_kW : Inport
  LcSOP_CurrPwr_kW : Inport  Port=2
  Enable : EnablePort  StatesWhenEnabling=reset
  Add1 : Sum  Inputs=+-
  Constant4 : Constant  Value=CcSOP_DischrgPwrFltLevel3Factor_numb
  Constant5 : Constant  Value=CcSOP_PwrFltHysFactor_numb
  Constant6 : Constant  Value=CcSOP_DischrgPwrFltLevel2Time_ms
  Constant7 : Constant  Value=SOP_RUNTIME_MS
  DebounceStartZero1 : AIWAYS_Powertrain_BMS_lib/Debounce & Delay/BMSDebounceStartZero
  Demux1 : Demux  Outputs=2
  Divide1 : Product  Inputs=**
  Mux : Mux  Inputs=2
  Relational Operator1 : RelationalOperator  Operator=<=  OutDataTypeStr=boolean
  LbSOP_DischrgPwrLevel32Level2_flg : Outport
  wires:
  Demux1/1 -> Relational Operator1/1
  Demux1/2 -> Divide1/1
  Mux/1 -> Demux1/1
  Constant4/1 -> Add1/1
  Constant5/1 -> Add1/2
  Add1/1 -> Divide1/2
  Divide1/1 -> Relational Operator1/2
  Relational Operator1/1 -> DebounceStartZero1/1
  Constant6/1 -> DebounceStartZero1/2, DebounceStartZero1/4
  Constant7/1 -> DebounceStartZero1/5, DebounceStartZero1/3
  DebounceStartZero1/1 -> LbSOP_DischrgPwrLevel32Level2_flg/1  "LbSOP_DischrgPwrLevel32Level2_flg"
  LcSOP_CurrPwr_kW/1 -> Mux/1
  LcSOP_PackDisChrgPeakTablePwr_kW/1 -> Mux/2

== system Copy_of_SOP/SOP/SOP_10ms/SOP_10ms_sys/PwrAlarm/DischrgState/DischrgStateNormal ==
  LcSOP_PackDisChrgPeakTablePwr_kW : Inport
  LcSOP_CurrPwr_kW : Inport  Port=2
  Enable : EnablePort  StatesWhenEnabling=reset
  Add : Sum
  Add1 : Sum  Inputs=+-
  Bus Creator : BusCreator  Inputs=2
  Bus Selector : BusSelector  OutputSignals=LcSOP_CurrPwr_kW,LcSOP_PackDisChrgPeakTablePwr_kW
  Bus Selector1 : BusSelector  OutputSignals=LcSOP_CurrPwr_kW,LcSOP_PackDisChrgPeakTablePwr_kW
  Constant : Constant  Value=CcSOP_DischrgPwrFltLevel1Factor_numb
  Constant1 : Constant  Value=CcSOP_PwrFltHysFactor_numb
  Constant2 : Constant  Value=CcSOP_DischrgPwrFltLevel1Time_ms
  Constant3 : Constant  Value=SOP_RUNTIME_MS
  Constant4 : Constant  Value=CcSOP_DischrgPwrFltThrld_kW
  DebounceStartZero : AIWAYS_Powertrain_BMS_lib/Debounce & Delay/BMSDebounceStartZero
  Divide : Product  Inputs=**
  Logical Operator : Logic  AllPortsSameDT=off  OutDataTypeStr=boolean
  Relational Operator : RelationalOperator  OutDataTypeStr=boolean
  Relational Operator1 : RelationalOperator  OutDataTypeStr=boolean
  LbSOP_DischrgPwrNormal2Level1_flg : Outport
  wires:
  DebounceStartZero/1 -> LbSOP_DischrgPwrNormal2Level1_flg/1  "LbSOP_DischrgPwrNormal2Level1_flg"
  Constant3/1 -> DebounceStartZero/3, DebounceStartZero/5
  Constant2/1 -> DebounceStartZero/2, DebounceStartZero/4
  Divide/1 -> Relational Operator/2
  Add/1 -> Divide/2
  Constant1/1 -> Add/2
  Constant/1 -> Add/1
  LcSOP_PackDisChrgPeakTablePwr_kW/1 -> Bus Creator/2  "LcSOP_PackDisChrgPeakTablePwr_kW"
  LcSOP_CurrPwr_kW/1 -> Bus Creator/1  "LcSOP_CurrPwr_kW"
  Bus Creator/1 -> Bus Selector1/1, Bus Selector/1
  Bus Selector/1 -> Relational Operator/1  "<LcSOP_CurrPwr_kW>"
  Bus Selector/2 -> Divide/1  "<LcSOP_PackDisChrgPeakTablePwr_kW>"
  Bus Selector1/1 -> Add1/1  "<LcSOP_CurrPwr_kW>"
  Bus Selector1/2 -> Add1/2  "<LcSOP_PackDisChrgPeakTablePwr_kW>"
  Add1/1 -> Relational Operator1/1
  Constant4/1 -> Relational Operator1/2
  Relational Operator1/1 -> Logical Operator/1
  Relational Operator/1 -> Logical Operator/2
  Logical Operator/1 -> DebounceStartZero/1

== system Copy_of_SOP/SOP/SOP_10ms/SOP_10ms_sys/PwrAlarm/FeedbackState/FeedbackStateFltLevel1 ==
  LcSOP_PackChrgPeakTablePwr_kW : Inport
  LcSOP_CurrPwr_kW : Inport  Port=2
  GbUDS_TestMode1_flg : Inport  Port=3
  Enable : EnablePort  StatesWhenEnabling=reset
  Add : Sum
  Add1 : Sum  Inputs=+-
  Add2 : Sum  Inputs=+-
  Constant : Constant  Value=CcSOP_FeedbackPwrFltLevel2Factor_numb
  Constant1 : Constant  Value=CcSOP_PwrFltHysFactor_numb
  Constant2 : Constant  Value=CcSOP_FeedbackPwrFltLevel2Time_ms
  Constant3 : Constant  Value=SOP_RUNTIME_MS
  Constant4 : Constant  Value=CcSOP_FeedbackPwrFltLevel1Factor_numb
  Constant5 : Constant  Value=CcSOP_PwrFltHysFactor_numb
  Constant6 : Constant  Value=CcSOP_FeedbackPwrFltLevel1Time_ms
  Constant7 : Constant  Value=SOP_RUNTIME_MS
  Constant8 : Constant  Value=CcSOP_FeedbackPwrFltThrld_kW
  Constant9 : Constant  Value=SOP_CONSTF1_NUMB
  DebounceStartZero : AIWAYS_Powertrain_BMS_lib/Debounce & Delay/BMSDebounceStartZero
  DebounceStartZero1 : AIWAYS_Powertrain_BMS_lib/Debounce & Delay/BMSDebounceStartZero
  Divide : Product  Inputs=**
  Divide1 : Product  Inputs=**
  Logical Operator2 : Logic  AllPortsSameDT=off  OutDataTypeStr=boolean
  Product : Product
  Relational Operator : RelationalOperator  Operator=<=  OutDataTypeStr=boolean
  Relational Operator1 : RelationalOperator  Operator=<=  OutDataTypeStr=boolean
  Relational Operator2 : RelationalOperator  OutDataTypeStr=boolean
  Terminator : Terminator
  LbSOP_FeedbackPwrLevel12Level2_flg : Outport
  LbSOP_FeedbackPwrLevel12Normal_flg : Outport  Port=2
  wires:
  Relational Operator1/1 -> DebounceStartZero1/1
  Logical Operator2/1 -> DebounceStartZero/1
  DebounceStartZero/1 -> LbSOP_FeedbackPwrLevel12Level2_flg/1  "LbSOP_FeedbackPwrLevel12Level2_flg"
  Constant3/1 -> DebounceStartZero/5, DebounceStartZero/3
  Constant2/1 -> DebounceStartZero/2, DebounceStartZero/4
  DebounceStartZero1/1 -> LbSOP_FeedbackPwrLevel12Normal_flg/1  "LbSOP_FeedbackPwrLevel12Normal_flg"
  Constant7/1 -> DebounceStartZero1/3, DebounceStartZero1/5
  Constant6/1 -> DebounceStartZero1/4, DebounceStartZero1/2
  Divide1/1 -> Relational Operator1/2
  Add1/1 -> Divide1/2
  Constant5/1 -> Add1/2
  Constant4/1 -> Add1/1
  Product/1 -> Relational Operator1/1, Relational Operator/2, Add2/1
  LcSOP_CurrPwr_kW/1 -> Product/2
  LcSOP_PackChrgPeakTablePwr_kW/1 -> Divide/1, Add2/2, Divide1/1
  Constant/1 -> Add/1
  Constant1/1 -> Add/2
  Add/1 -> Divide/2
  Relational Operator/1 -> Logical Operator2/1
  Divide/1 -> Relational Operator/1
  Add2/1 -> Relational Operator2/1
  Constant8/1 -> Relational Operator2/2
  Relational Operator2/1 -> Logical Operator2/2
  Constant9/1 -> Product/1
  GbUDS_TestMode1_flg/1 -> Terminator/1

== system Copy_of_SOP/SOP/SOP_10ms/SOP_10ms_sys/PwrAlarm/FeedbackState/FeedbackStateFltLevel2 ==
  LcSOP_PackChrgPeakTablePwr_kW : Inport
  LcSOP_CurrPwr_kW : Inport  Port=2
  GbUDS_TestMode1_flg : Inport  Port=3
  Enable : EnablePort  StatesWhenEnabling=reset
  Add : Sum
  Add1 : Sum  Inputs=+-
  Add2 : Sum  Inputs=+-
  Constant : Constant  Value=CcSOP_FeedbackPwrFltLevel3Factor_numb
  Constant1 : Constant  Value=CcSOP_PwrFltHysFactor_numb
  Constant10 : Constant  Value=CcSOP_PwrFltThrldTestMode_kW
  Constant2 : Constant  Value=CcSOP_FeedbackPwrFltLevel3Time_ms
  Constant3 : Constant  Value=SOP_RUNTIME_MS
  Constant4 : Constant  Value=CcSOP_FeedbackPwrFltLevel2Factor_numb
  Constant5 : Constant  Value=CcSOP_PwrFltHysFactor_numb
  Constant6 : Constant  Value=CcSOP_FeedbackPwrFltLevel2Time_ms
  Constant7 : Constant  Value=SOP_RUNTIME_MS
  Constant8 : Constant  Value=CcSOP_FeedbackPwrFltThrld_kW
  Constant9 : Constant  Value=SOP_CONSTF1_NUMB
  DebounceStartZero : AIWAYS_Powertrain_BMS_lib/Debounce & Delay/BMSDebounceStartZero
  DebounceStartZero1 : AIWAYS_Powertrain_BMS_lib/Debounce & Delay/BMSDebounceStartZero
  Divide : Product  Inputs=**
  Divide1 : Product  Inputs=**
  Logical Operator2 : Logic  AllPortsSameDT=off  OutDataTypeStr=boolean
  Product : Product
  Relational Operator : RelationalOperator  Operator=<=  OutDataTypeStr=boolean
  Relational Operator1 : RelationalOperator  Operator=<=  OutDataTypeStr=boolean
  Relational Operator2 : RelationalOperator  OutDataTypeStr=boolean
  Switch : Switch  Criteria=u2 ~= 0  Threshold=1  RndMeth=Zero
  LbSOP_FeedbackPwrLevel22Level3_flg : Outport
  LbSOP_FeedbackPwrLevel22Level1_flg : Outport  Port=2
  wires:
  Relational Operator1/1 -> DebounceStartZero1/1
  Logical Operator2/1 -> DebounceStartZero/1
  Constant6/1 -> DebounceStartZero1/2, DebounceStartZero1/4
  Constant7/1 -> DebounceStartZero1/5, DebounceStartZero1/3
  DebounceStartZero1/1 -> LbSOP_FeedbackPwrLevel22Level1_flg/1  "LbSOP_FeedbackPwrLevel22Level1_flg"
  Constant2/1 -> DebounceStartZero/4, DebounceStartZero/2
  Constant3/1 -> DebounceStartZero/3, DebounceStartZero/5
  DebounceStartZero/1 -> LbSOP_FeedbackPwrLevel22Level3_flg/1  "LbSOP_FeedbackPwrLevel22Level3_flg"
  Divide1/1 -> Relational Operator1/2
  Add1/1 -> Divide1/2
  Constant5/1 -> Add1/2
  Constant4/1 -> Add1/1
  Product/1 -> Add2/1, Relational Operator1/1, Relational Operator/2
  LcSOP_CurrPwr_kW/1 -> Product/2
  LcSOP_PackChrgPeakTablePwr_kW/1 -> Add2/2, Divide1/1, Divide/1
  Constant/1 -> Add/1
  Constant1/1 -> Add/2
  Add/1 -> Divide/2
  Relational Operator/1 -> Logical Operator2/1
  Divide/1 -> Relational Operator/1
  Add2/1 -> Relational Operator2/1
  Relational Operator2/1 -> Logical Operator2/2
  Constant9/1 -> Product/1
  GbUDS_TestMode1_flg/1 -> Switch/2
  Constant8/1 -> Switch/3
  Switch/1 -> Relational Operator2/2
  Constant10/1 -> Switch/1

== system Copy_of_SOP/SOP/SOP_10ms/SOP_10ms_sys/PwrAlarm/FeedbackState/FeedbackStateFltLevel3 ==
  LcSOP_PackChrgPeakTablePwr_kW : Inport
  LcSOP_CurrPwr_kW : Inport  Port=2
  GbUDS_TestMode1_flg : Inport  Port=3
  Enable : EnablePort  StatesWhenEnabling=reset
  Add : Sum  Inputs=+-
  Constant : Constant  Value=CcSOP_FeedbackPwrFltLevel3Factor_numb
  Constant1 : Constant  Value=CcSOP_PwrFltHysFactor_numb
  Constant6 : Constant  Value=CcSOP_FeedbackPwrFltLevel2Time_ms
  Constant7 : Constant  Value=SOP_RUNTIME_MS
  Constant8 : Constant  Value=SOP_CONSTF1_NUMB
  DebounceStartZero1 : AIWAYS_Powertrain_BMS_lib/Debounce & Delay/BMSDebounceStartZero
  Divide : Product  Inputs=**
  Product : Product
  Relational Operator : RelationalOperator  OutDataTypeStr=boolean
  Terminator : Terminator
  LbSOP_FeedbackPwrLevel32Level2_flg : Outport
  wires:
  Relational Operator/1 -> DebounceStartZero1/1
  DebounceStartZero1/1 -> LbSOP_FeedbackPwrLevel32Level2_flg/1  "LbSOP_FeedbackPwrLevel32Level2_flg"
  Constant7/1 -> DebounceStartZero1/3, DebounceStartZero1/5
  Constant6/1 -> DebounceStartZero1/4, DebounceStartZero1/2
  LcSOP_PackChrgPeakTablePwr_kW/1 -> Divide/1
  Constant/1 -> Add/1
  Constant1/1 -> Add/2
  Add/1 -> Divide/2
  Divide/1 -> Relational Operator/1
  Product/1 -> Relational Operator/2
  LcSOP_CurrPwr_kW/1 -> Product/2
  Constant8/1 -> Product/1
  GbUDS_TestMode1_flg/1 -> Terminator/1

== system Copy_of_SOP/SOP/SOP_10ms/SOP_10ms_sys/PwrAlarm/FeedbackState/FeedbackStateNormal ==
  LcSOP_PackChrgPeakTablePwr_kW : Inport
  LcSOP_CurrPwr_kW : Inport  Port=2
  GbUDS_TestMode1_flg : Inport  Port=3
  Enable : EnablePort  StatesWhenEnabling=reset
  Add : Sum
  Add1 : Sum  Inputs=+-
  Constant : Constant  Value=CcSOP_FeedbackPwrFltLevel1Factor_numb
  Constant1 : Constant  Value=CcSOP_PwrFltHysFactor_numb
  Constant2 : Constant  Value=CcSOP_FeedbackPwrFltLevel1Time_ms
  Constant3 : Constant  Value=SOP_RUNTIME_MS
  Constant4 : Constant  Value=CcSOP_FeedbackPwrFltThrld_kW
  Constant8 : Constant  Value=SOP_CONSTF1_NUMB
  DebounceStartZero : AIWAYS_Powertrain_BMS_lib/Debounce & Delay/BMSDebounceStartZero
  Divide : Product  Inputs=**
  Logical Operator : Logic  AllPortsSameDT=off  OutDataTypeStr=boolean
  Product : Product
  Relational Operator : RelationalOperator  Operator=<=  OutDataTypeStr=boolean
  Relational Operator1 : RelationalOperator  OutDataTypeStr=boolean
  Terminator : Terminator
  LbSOP_FeedbackPwrNormal2Level1_flg : Outport
  wires:
  LcSOP_CurrPwr_kW/1 -> Product/2
  LcSOP_PackChrgPeakTablePwr_kW/1 -> Add1/2, Divide/1
  Constant/1 -> Add/1
  Constant1/1 -> Add/2
  Add/1 -> Divide/2
  Constant2/1 -> DebounceStartZero/4, DebounceStartZero/2
  Constant3/1 -> DebounceStartZero/3, DebounceStartZero/5
  DebounceStartZero/1 -> LbSOP_FeedbackPwrNormal2Level1_flg/1  "LbSOP_FeedbackPwrNormal2Level1_flg"
  Relational Operator/1 -> Logical Operator/1
  Logical Operator/1 -> DebounceStartZero/1
  Divide/1 -> Relational Operator/1
  Product/1 -> Relational Operator/2, Add1/1
  Add1/1 -> Relational Operator1/1
  Constant4/1 -> Relational Operator1/2
  Relational Operator1/1 -> Logical Operator/2
  Constant8/1 -> Product/1
  GbUDS_TestMode1_flg/1 -> Terminator/1

== stateflow chart Copy_of_SOP/SOP/SOP_10ms/SOP_10ms_sys/PwrAlarm/FeedbackState/FeedbackState ==
  state FeedbackPwrNormal
    en:
    GeSOP_FeedbackPwrState_enum = Enum_SOPFeedbackPwrState.Enum_SOPFeedbackPwrState_Normal;
  state FeedbackPwrFltLevel1
    en:
    GeSOP_FeedbackPwrState_enum = Enum_SOPFeedbackPwrState.Enum_SOPFeedbackPwrState_FltLevel1;
  state FeedbackPwrFltLevel2
    en:
    GeSOP_FeedbackPwrState_enum = Enum_SOPFeedbackPwrState.Enum_SOPFeedbackPwrState_FltLevel2;
  state FeedbackPwrFltLevel3
    en:
    GeSOP_FeedbackPwrState_enum = Enum_SOPFeedbackPwrState.Enum_SOPFeedbackPwrState_FltLevel3;
  (default) -> FeedbackPwrNormal
  (junction 37) -> FeedbackPwrNormal
  (junction 29) -> (junction 37)
  FeedbackPwrNormal -> FeedbackPwrFltLevel1 : [ASWTYPE_TRUE == LbSOP_FeedbackPwrNormal2Level1_flg && ... ASWTYPE_TRUE ==LbSOP_FeedbackPwrFltFuncEn_flg]
  FeedbackPwrFltLevel1 -> FeedbackPwrNormal : [ASWTYPE_TRUE == LbSOP_FeedbackPwrLevel12Normal_flg && ... ASWTYPE_TRUE ==LbSOP_FeedbackPwrFltFuncEn_flg]
  FeedbackPwrFltLevel1 -> (junction 29) : [ASWTYPE_FALSE == LbSOP_FeedbackPwrFltFuncEn_flg]
  (junction 31) -> (junction 29)
  FeedbackPwrFltLevel1 -> FeedbackPwrFltLevel2 : [ASWTYPE_TRUE == LbSOP_FeedbackPwrLevel12Level2_flg && ... ASWTYPE_TRUE ==LbSOP_FeedbackPwrFltFuncEn_flg]
  FeedbackPwrFltLevel2 -> FeedbackPwrFltLevel1 : [ASWTYPE_TRUE == LbSOP_FeedbackPwrLevel22Level1_flg && ... ASWTYPE_TRUE ==LbSOP_FeedbackPwrFltFuncEn_flg]
  FeedbackPwrFltLevel2 -> (junction 31) : [ASWTYPE_FALSE == LbSOP_FeedbackPwrFltFuncEn_flg]
  (junction 33) -> (junction 31)
  FeedbackPwrFltLevel2 -> FeedbackPwrFltLevel3 : [ASWTYPE_TRUE == LbSOP_FeedbackPwrLevel22Level3_flg && ... ASWTYPE_TRUE ==LbSOP_FeedbackPwrFltFuncEn_flg]
  FeedbackPwrFltLevel3 -> FeedbackPwrFltLevel2 : [ASWTYPE_TRUE == LbSOP_FeedbackPwrLevel32Level2_flg && ... ASWTYPE_TRUE ==LbSOP_FeedbackPwrFltFuncEn_flg]
  FeedbackPwrFltLevel3 -> (junction 33) : [ASWTYPE_FALSE == LbSOP_FeedbackPwrFltFuncEn_flg]
  data: LbSOP_FeedbackPwrFltFuncEn_flg input; GeSOP_FeedbackPwrState_enum output; LbSOP_FeedbackPwrNormal2Level1_flg input; LbSOP_FeedbackPwrLevel12Level2_flg input; LbSOP_FeedbackPwrLevel12Normal_flg input; LbSOP_FeedbackPwrLevel22Level3_flg input; LbSOP_FeedbackPwrLevel22Level1_flg input; LbSOP_FeedbackPwrLevel32Level2_flg input; ASWTYPE_FALSE parameter; ASWTYPE_TRUE parameter

== stateflow chart Copy_of_SOP/SOP/SOP_10ms/SOP_10ms_sys/PwrAlarm/ChrgState/ChrgState ==
  state DisChrgPwrNormal
    en:
    GeSOP_ChrgPwrState_enum = Enum_SOPChrgPwrState.Enum_SOPChrgPwrState_Normal;
  state DisChrgPwrFltLevel1
    en:
    GeSOP_ChrgPwrState_enum = Enum_SOPChrgPwrState.Enum_SOPChrgPwrState_FltLevel1;
  state DisChrgPwrFltLevel2
    en:
    GeSOP_ChrgPwrState_enum = Enum_SOPChrgPwrState.Enum_SOPChrgPwrState_FltLevel2;
  state DisChrgPwrFltLevel3
    en:
    GeSOP_ChrgPwrState_enum = Enum_SOPChrgPwrState.Enum_SOPChrgPwrState_FltLevel3;
  (default) -> DisChrgPwrNormal
  (junction 37) -> DisChrgPwrNormal
  (junction 29) -> (junction 37)
  DisChrgPwrNormal -> DisChrgPwrFltLevel1 : [ASWTYPE_TRUE == LbSOP_ChrgPwrNormal2Level1_flg && ... ASWTYPE_TRUE ==LbSOP_ChrgCurrFltFuncEn_flg]
  DisChrgPwrFltLevel1 -> DisChrgPwrNormal : [ASWTYPE_TRUE == LbSOP_ChrgPwrLevel12Normal_flg && ... ASWTYPE_TRUE ==LbSOP_ChrgCurrFltFuncEn_flg]
  DisChrgPwrFltLevel1 -> (junction 29) : [ASWTYPE_FALSE == LbSOP_ChrgCurrFltFuncEn_flg]
  (junction 31) -> (junction 29)
  DisChrgPwrFltLevel1 -> DisChrgPwrFltLevel2 : [ASWTYPE_TRUE == LbSOP_ChrgPwrLevel12Level2_flg && ... ASWTYPE_TRUE ==LbSOP_ChrgCurrFltFuncEn_flg]
  DisChrgPwrFltLevel2 -> DisChrgPwrFltLevel1 : [ASWTYPE_TRUE == LbSOP_ChrgPwrLevel22Level1_flg && ... ASWTYPE_TRUE ==LbSOP_ChrgCurrFltFuncEn_flg]
  DisChrgPwrFltLevel2 -> (junction 31) : [ASWTYPE_FALSE == LbSOP_ChrgCurrFltFuncEn_flg]
  (junction 33) -> (junction 31)
  DisChrgPwrFltLevel2 -> DisChrgPwrFltLevel3 : [ASWTYPE_TRUE == LbSOP_ChrgPwrLevel22Level3_flg && ... ASWTYPE_TRUE ==LbSOP_ChrgCurrFltFuncEn_flg]
  DisChrgPwrFltLevel3 -> DisChrgPwrFltLevel2 : [ASWTYPE_TRUE == LbSOP_ChrgPwrLevel32Level2_flg && ... ASWTYPE_TRUE ==LbSOP_ChrgCurrFltFuncEn_flg]
  DisChrgPwrFltLevel3 -> (junction 33) : [ASWTYPE_FALSE == LbSOP_ChrgCurrFltFuncEn_flg]
  data: LbSOP_ChrgCurrFltFuncEn_flg input; GeSOP_ChrgPwrState_enum output; LbSOP_ChrgPwrNormal2Level1_flg input; LbSOP_ChrgPwrLevel12Level2_flg input; LbSOP_ChrgPwrLevel12Normal_flg input; LbSOP_ChrgPwrLevel22Level3_flg input; LbSOP_ChrgPwrLevel22Level1_flg input; LbSOP_ChrgPwrLevel32Level2_flg input; ASWTYPE_FALSE parameter; ASWTYPE_TRUE parameter

== stateflow chart Copy_of_SOP/SOP/SOP_10ms/SOP_10ms_sys/PwrAlarm/DischrgState/DischrgState ==
  state DisChrgPwrNormal
    en:
    GeSOP_DisChrgPwrState_enum = Enum_SOPDisChrgPwrState.Enum_SOPDisChrgPwrState_Normal;
  state DisChrgPwrFltLevel1
    en:
    GeSOP_DisChrgPwrState_enum = Enum_SOPDisChrgPwrState.Enum_SOPDisChrgPwrState_FltLevel1;
  state DisChrgPwrFltLevel2
    en:
    GeSOP_DisChrgPwrState_enum = Enum_SOPDisChrgPwrState.Enum_SOPDisChrgPwrState_FltLevel2;
  state DisChrgPwrFltLevel3
    en:
    GeSOP_DisChrgPwrState_enum = Enum_SOPDisChrgPwrState.Enum_SOPDisChrgPwrState_FltLevel3;
  (default) -> DisChrgPwrNormal
  (junction 37) -> DisChrgPwrNormal
  (junction 29) -> (junction 37)
  DisChrgPwrNormal -> DisChrgPwrFltLevel1 : [ASWTYPE_TRUE == LbSOP_DischrgPwrNormal2Level1_flg && ... ASWTYPE_TRUE ==LbSOP_DischrgPwrFltFuncEn_flg]
  DisChrgPwrFltLevel1 -> DisChrgPwrNormal : [ASWTYPE_TRUE == LbSOP_DischrgPwrLevel12Normal_flg && ... ASWTYPE_TRUE ==LbSOP_DischrgPwrFltFuncEn_flg]
  DisChrgPwrFltLevel1 -> (junction 29) : [ASWTYPE_FALSE == LbSOP_DischrgPwrFltFuncEn_flg]
  (junction 31) -> (junction 29)
  DisChrgPwrFltLevel1 -> DisChrgPwrFltLevel2 : [ASWTYPE_TRUE == LbSOP_DischrgPwrLevel12Level2_flg && ... ASWTYPE_TRUE ==LbSOP_DischrgPwrFltFuncEn_flg]
  DisChrgPwrFltLevel2 -> DisChrgPwrFltLevel1 : [ASWTYPE_TRUE == LbSOP_DischrgPwrLevel22Level1_flg && ... ASWTYPE_TRUE ==LbSOP_DischrgPwrFltFuncEn_flg]
  DisChrgPwrFltLevel2 -> (junction 31) : [ASWTYPE_FALSE == LbSOP_DischrgPwrFltFuncEn_flg]
  (junction 33) -> (junction 31)
  DisChrgPwrFltLevel2 -> DisChrgPwrFltLevel3 : [ASWTYPE_TRUE == LbSOP_DischrgPwrLevel22Level3_flg && ... ASWTYPE_TRUE ==LbSOP_DischrgPwrFltFuncEn_flg]
  DisChrgPwrFltLevel3 -> DisChrgPwrFltLevel2 : [ASWTYPE_TRUE == LbSOP_DischrgPwrLevel32Level2_flg && ... ASWTYPE_TRUE ==LbSOP_DischrgPwrFltFuncEn_flg]
  DisChrgPwrFltLevel3 -> (junction 33) : [ASWTYPE_FALSE == LbSOP_DischrgPwrFltFuncEn_flg]
  data: LbSOP_DischrgPwrFltFuncEn_flg input; GeSOP_DisChrgPwrState_enum output; LbSOP_DischrgPwrNormal2Level1_flg input; LbSOP_DischrgPwrLevel12Level2_flg input; LbSOP_DischrgPwrLevel12Normal_flg input; LbSOP_DischrgPwrLevel22Level3_flg input; LbSOP_DischrgPwrLevel22Level1_flg input; LbSOP_DischrgPwrLevel32Level2_flg input; ASWTYPE_FALSE parameter; ASWTYPE_TRUE parameter

== stateflow chart Copy_of_SOP/Chart ==
  (default) -> (junction 1)
  (junction 1) -> (junction 3) : {SOP_SOP_10ms;}
  events: output FUNCTION_CALL_EVENT
