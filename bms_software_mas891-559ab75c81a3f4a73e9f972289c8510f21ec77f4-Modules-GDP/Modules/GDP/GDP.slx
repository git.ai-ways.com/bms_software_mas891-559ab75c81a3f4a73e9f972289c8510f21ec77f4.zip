simulink model "GDP"  (R2017b)
settings: Solver=FixedStepDiscrete  StartTime=0.0  StopTime=10.0  FixedStep=0.01  RelTol=1e-3  EnableMultiTasking=on
undefined symbols (not defined in the file): ASWTYPE_FALSE, ASWTYPE_TRUE, CcGDP_CHMRecDelay_ms, CcGDP_DCCANBusOffFltTi_ms, Enum_DCCDCConnSt, Enum_LDPCC2St, GDP_CONST1_NUMB, GDP_RUNTIME250_MS, GDP_RUNTIME_MS
libraries: AIWAYS_Powertrain_BMS_lib x69
(part 3 of 3)

== system GDP/DCR/CCS_50ms/CCS_50ms_sys/ CCSRecOnce/CCSMsg ==
  GbGDP_CCSMsgUpd_flg : Inport
  Enable : EnablePort  StatesWhenEnabling=reset
  Logical Operator2 : Logic  Operator=OR  AllPortsSameDT=off  OutDataTypeStr=boolean
  Unit Delay : UnitDelay  SampleTime=-1  StateName=StateName
  LbGDP_CCSRecOnce_flg : Outport
  wires:
  Logical Operator2/1 -> LbGDP_CCSRecOnce_flg/1, Unit Delay/1  "LbGDP_CCSRecOnce_flg"
  GbGDP_CCSMsgUpd_flg/1 -> Logical Operator2/1
  Unit Delay/1 -> Logical Operator2/2

== system GDP/DCR/CEM_250ms/CEM_250ms_sys/ CEMRecOnce/CEMMsg ==
  GbGDP_CEMMsgUpd_flg : Inport
  Enable : EnablePort  StatesWhenEnabling=reset
  Logical Operator2 : Logic  Operator=OR  AllPortsSameDT=off  OutDataTypeStr=boolean
  Unit Delay : UnitDelay  SampleTime=-1  StateName=StateName
  LbGDP_CEMRecOnce_flg : Outport
  wires:
  Logical Operator2/1 -> LbGDP_CEMRecOnce_flg/1, Unit Delay/1  "LbGDP_CEMRecOnce_flg"
  GbGDP_CEMMsgUpd_flg/1 -> Logical Operator2/1
  Unit Delay/1 -> Logical Operator2/2

== system GDP/DCR/CHM_250ms/CHM_250ms_sys/ CHMRecOnce/CHMMsg ==
  GbGDP_CHMMsgUpd_flg : Inport
  Enable : EnablePort  StatesWhenEnabling=reset
  Logical Operator2 : Logic  Operator=OR  AllPortsSameDT=off  OutDataTypeStr=boolean
  Unit Delay : UnitDelay  SampleTime=-1  StateName=StateName
  LbGDP_CHMRecOnce_flg : Outport
  wires:
  Logical Operator2/1 -> LbGDP_CHMRecOnce_flg/1, Unit Delay/1  "LbGDP_CHMRecOnce_flg"
  Unit Delay/1 -> Logical Operator2/2
  GbGDP_CHMMsgUpd_flg/1 -> Logical Operator2/1

== system GDP/DCR/CML_500ms/CML_500ms_sys/ CMLRecOnce/CMLMsg ==
  GbGDP_CMLMsgUpd_flg : Inport
  Enable : EnablePort  StatesWhenEnabling=reset
  Logical Operator2 : Logic  Operator=OR  AllPortsSameDT=off  OutDataTypeStr=boolean
  Unit Delay : UnitDelay  SampleTime=-1  StateName=StateName
  LbGDP_CMLRecOnce_flg : Outport
  wires:
  Logical Operator2/1 -> LbGDP_CMLRecOnce_flg/1, Unit Delay/1  "LbGDP_CMLRecOnce_flg"
  GbGDP_CMLMsgUpd_flg/1 -> Logical Operator2/1
  Unit Delay/1 -> Logical Operator2/2

== system GDP/DCR/CRM_250ms/CRM_250ms_sys/ CRMRecOnce/CRMMsg ==
  GbGDP_CRMMsgUpd_flg : Inport
  Enable : EnablePort  StatesWhenEnabling=reset
  Logical Operator2 : Logic  Operator=OR  AllPortsSameDT=off  OutDataTypeStr=boolean
  Unit Delay : UnitDelay  Priority=2  SampleTime=-1  StateName=StateName
  LbGDP_CRMRecOnce_flg : Outport
  wires:
  Logical Operator2/1 -> LbGDP_CRMRecOnce_flg/1, Unit Delay/1  "LbGDP_CRMRecOnce_flg"
  GbGDP_CRMMsgUpd_flg/1 -> Logical Operator2/1
  Unit Delay/1 -> Logical Operator2/2

== system GDP/DCR/CRO_50ms/CRO_50ms_sys/ CRORecOnce/CROMsg ==
  GbGDP_CROMsgUpd_flg : Inport
  Enable : EnablePort  StatesWhenEnabling=reset
  Logical Operator2 : Logic  Operator=OR  AllPortsSameDT=off  OutDataTypeStr=boolean
  Unit Delay : UnitDelay  SampleTime=-1  StateName=StateName
  LbGDP_CRORecOnce_flg : Outport
  wires:
  Logical Operator2/1 -> LbGDP_CRORecOnce_flg/1, Unit Delay/1  "LbGDP_CRORecOnce_flg"
  GbGDP_CROMsgUpd_flg/1 -> Logical Operator2/1
  Unit Delay/1 -> Logical Operator2/2

== system GDP/DCR/CSD_250ms/CSD_250ms_sys/ CSDRecOnce/CSDMsg ==
  GbGDP_CSDMsgUpd_flg : Inport
  Enable : EnablePort  StatesWhenEnabling=reset
  Logical Operator2 : Logic  Operator=OR  AllPortsSameDT=off  OutDataTypeStr=boolean
  Unit Delay : UnitDelay  SampleTime=-1  StateName=StateName
  LbGDP_CSDRecOnce_flg : Outport
  wires:
  Logical Operator2/1 -> LbGDP_CSDRecOnce_flg/1, Unit Delay/1  "LbGDP_CSDRecOnce_flg"
  GbGDP_CSDMsgUpd_flg/1 -> Logical Operator2/1
  Unit Delay/1 -> Logical Operator2/2

== system GDP/DCR/CST_10ms/CST_10ms_sys/ CSTRecOnce/CSTMsg ==
  GbGDP_CSTMsgUpd_flg : Inport
  Enable : EnablePort  StatesWhenEnabling=reset
  Logical Operator2 : Logic  Operator=OR  AllPortsSameDT=off  OutDataTypeStr=boolean
  Unit Delay : UnitDelay  SampleTime=-1  StateName=StateName
  LbGDP_CSTRecOnce_flg : Outport
  wires:
  Logical Operator2/1 -> LbGDP_CSTRecOnce_flg/1, Unit Delay/1  "LbGDP_CSTRecOnce_flg"
  GbGDP_CSTMsgUpd_flg/1 -> Logical Operator2/1
  Unit Delay/1 -> Logical Operator2/2

== system GDP/DCR/CTS_500ms/CTS_500ms_sys/ CTSRecOnce/CTSMsg ==
  GbGDP_CTSMsgUpd_flg : Inport
  Enable : EnablePort  StatesWhenEnabling=reset
  Logical Operator2 : Logic  Operator=OR  AllPortsSameDT=off  OutDataTypeStr=boolean
  Unit Delay : UnitDelay  SampleTime=-1  StateName=StateName
  LbGDP_CTSRecOnce_flg : Outport
  wires:
  Logical Operator2/1 -> LbGDP_CTSRecOnce_flg/1, Unit Delay/1  "LbGDP_CTSRecOnce_flg"
  GbGDP_CTSMsgUpd_flg/1 -> Logical Operator2/1
  Unit Delay/1 -> Logical Operator2/2
