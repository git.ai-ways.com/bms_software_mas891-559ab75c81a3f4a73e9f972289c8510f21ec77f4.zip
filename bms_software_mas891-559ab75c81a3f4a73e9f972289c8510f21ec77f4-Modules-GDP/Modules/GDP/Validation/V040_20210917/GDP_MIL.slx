simulink model "GDP_MIL"  (R2017b)
settings: Solver=FixedStepDiscrete  StartTime=0.0  StopTime=10.0  FixedStep=0.01  RelTol=1e-3  EnableMultiTasking=on
undefined symbols (not defined in the file): ASWTYPE_FALSE, ASWTYPE_TRUE, CcGDP_CHMRecDelay_ms, CcGDP_DCCANBusOffFltTi_ms, Enum_DCCDCConnSt, Enum_LDPCC2St, GDP_CONST1_NUMB, GDP_RUNTIME250_MS, GDP_RUNTIME_MS
libraries: AIWAYS_Powertrain_BMS_lib x69
(part 3 of 3)

== system GDP_MIL/DCR/CCS_50ms/CCS_50ms_sys/ CCSRecOnce/CCSMsg ==
  GbGDP_CCSMsgUpd_flg : Inport
  Enable : EnablePort  StatesWhenEnabling=reset
  Logical Operator2 : Logic  Operator=OR  AllPortsSameDT=off  OutDataTypeStr=boolean
  Unit Delay : UnitDelay  SampleTime=-1  StateName=StateName
  LbGDP_CCSRecOnce_flg : Outport
  wires:
  Logical Operator2/1 -> LbGDP_CCSRecOnce_flg/1, Unit Delay/1  "LbGDP_CCSRecOnce_flg"
  GbGDP_CCSMsgUpd_flg/1 -> Logical Operator2/1
  Unit Delay/1 -> Logical Operator2/2

== system GDP_MIL/DCR/CEM_250ms/CEM_250ms_sys/ CEMRecOnce/CEMMsg ==
  GbGDP_CEMMsgUpd_flg : Inport
  Enable : EnablePort  StatesWhenEnabling=reset
  Logical Operator2 : Logic  Operator=OR  AllPortsSameDT=off  OutDataTypeStr=boolean
  Unit Delay : UnitDelay  SampleTime=-1  StateName=StateName
  LbGDP_CEMRecOnce_flg : Outport
  wires:
  Logical Operator2/1 -> LbGDP_CEMRecOnce_flg/1, Unit Delay/1  "LbGDP_CEMRecOnce_flg"
  GbGDP_CEMMsgUpd_flg/1 -> Logical Operator2/1
  Unit Delay/1 -> Logical Operator2/2

== system GDP_MIL/DCR/CHM_250ms/CHM_250ms_sys/ CHMRecOnce/CHMMsg ==
  GbGDP_CHMMsgUpd_flg : Inport
  Enable : EnablePort  StatesWhenEnabling=reset
  Logical Operator2 : Logic  Operator=OR  AllPortsSameDT=off  OutDataTypeStr=boolean
  Unit Delay : UnitDelay  SampleTime=-1  StateName=StateName
  LbGDP_CHMRecOnce_flg : Outport
  wires:
  Logical Operator2/1 -> LbGDP_CHMRecOnce_flg/1, Unit Delay/1  "LbGDP_CHMRecOnce_flg"
  Unit Delay/1 -> Logical Operator2/2
  GbGDP_CHMMsgUpd_flg/1 -> Logical Operator2/1

== system GDP_MIL/DCR/CML_500ms/CML_500ms_sys/ CMLRecOnce/CMLMsg ==
  GbGDP_CMLMsgUpd_flg : Inport
  Enable : EnablePort  StatesWhenEnabling=reset
  Logical Operator2 : Logic  Operator=OR  AllPortsSameDT=off  OutDataTypeStr=boolean
  Unit Delay : UnitDelay  SampleTime=-1  StateName=StateName
  LbGDP_CMLRecOnce_flg : Outport
  wires:
  Logical Operator2/1 -> LbGDP_CMLRecOnce_flg/1, Unit Delay/1  "LbGDP_CMLRecOnce_flg"
  GbGDP_CMLMsgUpd_flg/1 -> Logical Operator2/1
  Unit Delay/1 -> Logical Operator2/2

== system GDP_MIL/DCR/CRM_250ms/CRM_250ms_sys/ CRMRecOnce/CRMMsg ==
  GbGDP_CRMMsgUpd_flg : Inport
  Enable : EnablePort  StatesWhenEnabling=reset
  Logical Operator2 : Logic  Operator=OR  AllPortsSameDT=off  OutDataTypeStr=boolean
  Unit Delay : UnitDelay  Priority=2  SampleTime=-1  StateName=StateName
  LbGDP_CRMRecOnce_flg : Outport
  wires:
  Logical Operator2/1 -> LbGDP_CRMRecOnce_flg/1, Unit Delay/1  "LbGDP_CRMRecOnce_flg"
  GbGDP_CRMMsgUpd_flg/1 -> Logical Operator2/1
  Unit Delay/1 -> Logical Operator2/2

== system GDP_MIL/DCR/CRO_50ms/CRO_50ms_sys/ CRORecOnce/CROMsg ==
  GbGDP_CROMsgUpd_flg : Inport
  Enable : EnablePort  StatesWhenEnabling=reset
  Logical Operator2 : Logic  Operator=OR  AllPortsSameDT=off  OutDataTypeStr=boolean
  Unit Delay : UnitDelay  SampleTime=-1  StateName=StateName
  LbGDP_CRORecOnce_flg : Outport
  wires:
  Logical Operator2/1 -> LbGDP_CRORecOnce_flg/1, Unit Delay/1  "LbGDP_CRORecOnce_flg"
  GbGDP_CROMsgUpd_flg/1 -> Logical Operator2/1
  Unit Delay/1 -> Logical Operator2/2

== system GDP_MIL/DCR/CSD_250ms/CSD_250ms_sys/ CSDRecOnce/CSDMsg ==
  GbGDP_CSDMsgUpd_flg : Inport
  Enable : EnablePort  StatesWhenEnabling=reset
  Logical Operator2 : Logic  Operator=OR  AllPortsSameDT=off  OutDataTypeStr=boolean
  Unit Delay : UnitDelay  SampleTime=-1  StateName=StateName
  LbGDP_CSDRecOnce_flg : Outport
  wires:
  Logical Operator2/1 -> LbGDP_CSDRecOnce_flg/1, Unit Delay/1  "LbGDP_CSDRecOnce_flg"
  GbGDP_CSDMsgUpd_flg/1 -> Logical Operator2/1
  Unit Delay/1 -> Logical Operator2/2

== system GDP_MIL/DCR/CST_10ms/CST_10ms_sys/ CSTRecOnce/CSTMsg ==
  GbGDP_CSTMsgUpd_flg : Inport
  Enable : EnablePort  StatesWhenEnabling=reset
  Logical Operator2 : Logic  Operator=OR  AllPortsSameDT=off  OutDataTypeStr=boolean
  Unit Delay : UnitDelay  SampleTime=-1  StateName=StateName
  LbGDP_CSTRecOnce_flg : Outport
  wires:
  Logical Operator2/1 -> LbGDP_CSTRecOnce_flg/1, Unit Delay/1  "LbGDP_CSTRecOnce_flg"
  GbGDP_CSTMsgUpd_flg/1 -> Logical Operator2/1
  Unit Delay/1 -> Logical Operator2/2

== system GDP_MIL/DCR/CTS_500ms/CTS_500ms_sys/ CTSRecOnce/CTSMsg ==
  GbGDP_CTSMsgUpd_flg : Inport
  Enable : EnablePort  StatesWhenEnabling=reset
  Logical Operator2 : Logic  Operator=OR  AllPortsSameDT=off  OutDataTypeStr=boolean
  Unit Delay : UnitDelay  SampleTime=-1  StateName=StateName
  LbGDP_CTSRecOnce_flg : Outport
  wires:
  Logical Operator2/1 -> LbGDP_CTSRecOnce_flg/1, Unit Delay/1  "LbGDP_CTSRecOnce_flg"
  GbGDP_CTSMsgUpd_flg/1 -> Logical Operator2/1
  Unit Delay/1 -> Logical Operator2/2

== stateflow chart GDP_MIL/GDP_Schedule ==
  (default) -> (junction 50)
  (junction 50) -> (junction 13) : { GDP_CST_10ms; GDP_BusOff_10ms; GDP_CSTUpdateClr_10ms; }
  (junction 13) -> (junction 150) : { TimeCounter50ms ++; TimeCounter250ms ++; TimeCounter500ms ++; }
  (junction 150) -> (junction 422) : [TimeCounter50ms >= Const50ms]
  (junction 150) -> (junction 424)
  (junction 422) -> (junction 424) : { GDP_CRO_50ms; GDP_CCS_50ms; GDP_CCSUpdateClr_50ms; GDP_CROUpdateClr_50ms; TimeCounter50ms = 0; }
  (junction 424) -> (junction 503) : [TimeCounter250ms >= Const250ms]
  (junction 424) -> (junction 505)
  (junction 503) -> (junction 505) : {GDP_CHM_250ms; GDP_CRM_250ms; GDP_CSD_250ms; GDP_CEM_250ms; GDP_CEMUpdateClr_250ms; GDP_CHMUpdateClr_250ms; GDP_CRMUpdateClr_250ms; GDP_CSDUpdateClr_250ms; TimeCounter250ms = 0; }
  (junction 505) -> (junction 509) : [TimeCounter500ms >= Const500ms]
  (junction 505) -> (junction 512)
  (junction 509) -> (junction 512) : {GDP_CTS_500ms; GDP_CML_500ms; GDP_CMLUpdateClr_500ms; GDP_CTSUpdateClr_500ms; TimeCounter500ms = 0; }
  data: TimeCounter50ms local uint8; Const250ms constant uint8 =25; TimeCounter250ms local uint8; Const50ms constant uint8 =5; Const500ms constant uint8 =50; TimeCounter500ms local uint8; TimeCounter250ms1 local uint8
  events: output FUNCTION_CALL_EVENT; output FUNCTION_CALL_EVENT; output FUNCTION_CALL_EVENT; output FUNCTION_CALL_EVENT; output FUNCTION_CALL_EVENT; output FUNCTION_CALL_EVENT; output FUNCTION_CALL_EVENT; output FUNCTION_CALL_EVENT; output FUNCTION_CALL_EVENT; output FUNCTION_CALL_EVENT; output FUNCTION_CALL_EVENT; output FUNCTION_CALL_EVENT; output FUNCTION_CALL_EVENT; output FUNCTION_CALL_EVENT; output FUNCTION_CALL_EVENT; output FUNCTION_CALL_EVENT; output FUNCTION_CALL_EVENT; output FUNCTION_CALL_EVENT; output FUNCTION_CALL_EVENT
